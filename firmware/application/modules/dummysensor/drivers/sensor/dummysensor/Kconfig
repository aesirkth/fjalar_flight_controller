## firmware/application/modules/dummysensor/drivers/sensor/dummysensor/Kconfig
```kconfig
config DUMMYSENSOR
	bool "dummy sensor"
	default y
	depends on DT_HAS_AESIR_DUMMYSENSOR_ENABLED
```
